Commit message: One bug left (probably)

File: src/ur10e_rg2/ur10e_rg2_description/ur10e_rg2.urdf (robot description, URDF)
Before this commit: robot ur10e_rg2, 19 links, 18 joints
Joints:
- joint robot_shoulder_lift_joint: origin xyz=0 0 0 rpy=1.570796327 0 0 -> xyz=0 0 0 rpy=1.570796327 14.12 0
